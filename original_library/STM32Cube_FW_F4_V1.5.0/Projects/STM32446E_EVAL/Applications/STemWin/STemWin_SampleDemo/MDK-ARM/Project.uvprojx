# Keil uVision project Project.uvprojx, settings and files
target STM32446E_EVAL (ARM-ADS)
  device: STM32F446ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32446E_EVAL
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ..\Inc;..\Demo;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL;..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152;..\..\..\..\..\..\Drivers\BSP\Components\ili9325;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\Components;..\..\..\..\..\..\Middlewares\ST\STemWin\inc;..\..\..\..\..\..\Utilities;..\..\..\..\..\..\Utilities\Fonts
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/Demo
    ../Demo/: GUIDEMO_Intro.c GUIDEMO_Automotive.c GUIDEMO_Start.c GUIDEMO_ZoomAndRotate.c GUIDEMO_Fading.c GUIDEMO_Cursor.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Speedometer.c GUIDEMO_WashingMachine.c GUIDEMO_TransparentDialog.c GUIDEMO.c GUIDEMO_Resource.c GUIDEMO_Conf.c GUIDEMO_VScreen.c GUIDEMO_Bitmap.c GUIDEMO_RadialMenu.c GUIDEMO_Listview.c GUIDEMO_Speed.c GUIDEMO_Skinning.c GUIDEMO_AntialiasedText.c GUIDEMO_Graph.c GUIDEMO_BarGraph.c GUIDEMO_ColorBar.c GUIDEMO_Treeview.c
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: calibration.c stm32f4xx_it.c rtc.c main.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_crc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sram.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_flash_ex.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_io.c stm32446e_eval.c stm32446e_eval_ts.c
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm32446e_eval.c GUIConf_stm32446e_eval.c
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin526_CM4_Keil.lib
software components: CMSIS:CORE 3.40.0
