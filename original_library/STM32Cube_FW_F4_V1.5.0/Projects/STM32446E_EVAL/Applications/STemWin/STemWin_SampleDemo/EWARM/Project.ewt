<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32446E_EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <group>
      <name>Demo</name>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_AntialiasedText.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Automotive.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_BarGraph.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Bitmap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_ColorBar.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Conf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Cursor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Fading.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Graph.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_IconView.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_ImageFlow.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Intro.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Listview.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_RadialMenu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Resource.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Skinning.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Speed.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Speedometer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Start.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_TransparentDialog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_Treeview.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_VScreen.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_WashingMachine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Demo\GUIDEMO_ZoomAndRotate.c</name>
      </file>
    </group>
    <group>
      <name>EWARM</name>
      <file>
        <name>$PROJ_DIR$\startup_stm32f446xx.s</name>
      </file>
    </group>
    <group>
      <name>User</name>
      <file>
        <name>$PROJ_DIR$\..\Src\calibration.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Src\stm32f4xx_it.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\..\readme.txt</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <group>
      <name>BSP</name>
      <group>
        <name>Components</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\ili9325\ili9325.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152\mfxstm32l152.c</name>
        </file>
      </group>
      <group>
        <name>STM32446E_EVAL</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL\stm32446e_eval.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL\stm32446e_eval_io.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL\stm32446e_eval_ts.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\Src\system_stm32f4xx.c</name>
      </file>
    </group>
    <group>
      <name>STM32F4xx_HAL_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_fmpi2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_fmpi2c_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_pwr_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rtc_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_sram.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Src\stm32f4xx_ll_fmc.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Middlewares</name>
    <group>
      <name>STemWin</name>
      <group>
        <name>Config</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\OS\GUI_X.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\GUIConf_stm32446e_eval.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Src\LCDConf_stm32446e_eval.c</name>
        </file>
      </group>
      <group>
        <name>inc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\BUTTON.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\BUTTON_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\CALENDAR.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\CHECKBOX.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\CHECKBOX_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\CHOOSECOLOR.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\CHOOSEFILE.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\DIALOG.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\DIALOG_Intern.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\DROPDOWN.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\DROPDOWN_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\EDIT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\EDIT_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\FRAMEWIN.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\FRAMEWIN_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\Global.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GRAPH.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GRAPH_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_ARRAY.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_ARRAY_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_BMP_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_ConfDefaults.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_Debug.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_FontIntern.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_GIF_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_HOOK.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_JPEG_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_SetOrientation.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_SetOrientationCX.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_SPRITE_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_Type.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_Version.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUI_VNC.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_DCache.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_DCache_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Dist.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_FlexColor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_FlexColor_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Generic.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Lin.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Lin_Opt_16.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Lin_Opt_24.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Lin_Opt_32.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Lin_Opt_8.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Lin_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_NoOpt_1_8.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_Template.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_TemplateI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\GUIDRV_TemplateI_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\HEADER.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\HEADER_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\ICONVIEW.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\ICONVIEW_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\IMAGE.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\IMAGE_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LCD.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LCD_ConfDefaults.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LCD_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LCD_Protected.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LCD_SIM.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LISTBOX.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LISTBOX_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LISTVIEW.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LISTVIEW_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LISTWHEEL.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\LISTWHEEL_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\MENU.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\MENU_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\MESSAGEBOX.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\MULTIEDIT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\MULTIPAGE.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\MULTIPAGE_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\PROGBAR.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\PROGBAR_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\RADIO.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\RADIO_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\SCROLLBAR.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\SCROLLBAR_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\SLIDER.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\SLIDER_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\SPINBOX.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\SPINBOX_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\TEXT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\TEXT_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\TREEVIEW.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\TREEVIEW_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\WIDGET.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\WINDOW_Private.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\WM.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\WM_GUI.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\inc\WM_Intern.h</name>
        </file>
      </group>
      <group>
        <name>Lib</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\..\Middlewares\ST\STemWin\Lib\STemWin526_CM4_IAR.a</name>
        </file>
      </group>
    </group>
  </group>
</project>


